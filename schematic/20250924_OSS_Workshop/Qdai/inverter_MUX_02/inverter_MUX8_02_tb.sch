v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -740 -400 -580 -400 {lab=VDD}
N -740 -630 -740 -400 {lab=VDD}
N -430 -740 -430 -500 {lab=#net1}
N -430 -740 -240 -740 {lab=#net1}
N -430 -470 -410 -470 {lab=#net2}
N -410 -640 -410 -470 {lab=#net2}
N -410 -640 -240 -640 {lab=#net2}
N -430 -440 -390 -440 {lab=#net3}
N -390 -540 -390 -440 {lab=#net3}
N -390 -540 -240 -540 {lab=#net3}
N -430 -410 -370 -410 {lab=#net4}
N -370 -440 -370 -410 {lab=#net4}
N -370 -440 -240 -440 {lab=#net4}
N -430 -380 -370 -380 {lab=#net5}
N -370 -380 -370 -350 {lab=#net5}
N -370 -350 -370 -340 {lab=#net5}
N -370 -340 -240 -340 {lab=#net5}
N -430 -350 -400 -350 {lab=#net6}
N -430 -320 -410 -320 {lab=#net7}
N -410 -320 -410 -140 {lab=#net7}
N -410 -140 -240 -140 {lab=#net7}
N -430 -290 -430 -40 {lab=#net8}
N -430 -40 -240 -40 {lab=#net8}
N -400 -350 -390 -350 {lab=#net6}
N -390 -350 -390 -240 {lab=#net6}
N -390 -240 -240 -240 {lab=#net6}
N -120 -740 -80 -740 {lab=#net9}
N -80 -740 -80 30 {lab=#net9}
N -740 30 -80 30 {lab=#net9}
N -120 -640 -40 -640 {lab=#net10}
N -40 -640 -40 70 {lab=#net10}
N -540 70 -40 70 {lab=#net10}
N -120 -540 0 -540 {lab=#net11}
N -0 -540 -0 110 {lab=#net11}
N -340 110 -0 110 {lab=#net11}
N -120 -440 40 -440 {lab=#net12}
N 40 -440 40 150 {lab=#net12}
N -130 150 40 150 {lab=#net12}
N -120 -340 80 -340 {lab=#net13}
N 80 -340 80 150 {lab=#net13}
N 80 150 100 150 {lab=#net13}
N 100 150 110 150 {lab=#net13}
N -120 -240 120 -240 {lab=#net14}
N 120 -240 120 100 {lab=#net14}
N 120 100 120 110 {lab=#net14}
N 120 110 320 110 {lab=#net14}
N -120 -140 160 -140 {lab=#net15}
N 160 -140 160 60 {lab=#net15}
N 160 60 160 70 {lab=#net15}
N 160 70 520 70 {lab=#net15}
N -120 -40 200 -40 {lab=#net16}
N 200 -40 200 30 {lab=#net16}
N 200 30 720 30 {lab=#net16}
N 310 -410 400 -410 {lab=vin}
N 310 -690 310 -410 {lab=vin}
N 550 -510 600 -510 {lab=#net17}
N 600 -510 600 210 {lab=#net17}
N -790 210 600 210 {lab=#net17}
N 550 -480 640 -480 {lab=#net18}
N 640 -480 640 250 {lab=#net18}
N -590 250 640 250 {lab=#net18}
N 550 -450 680 -450 {lab=#net19}
N 680 -450 680 280 {lab=#net19}
N -390 280 680 280 {lab=#net19}
N 550 -420 720 -420 {lab=#net20}
N 550 -390 760 -390 {lab=#net21}
N 760 -390 760 340 {lab=#net21}
N 60 340 760 340 {lab=#net21}
N 550 -360 800 -360 {lab=#net22}
N 800 -360 800 370 {lab=#net22}
N 270 370 800 370 {lab=#net22}
N 550 -330 840 -330 {lab=#net23}
N 470 400 840 400 {lab=#net23}
N 840 -330 840 400 {lab=#net23}
N 550 -300 880 -300 {lab=#net24}
N 880 -300 880 430 {lab=#net24}
N 670 430 880 430 {lab=#net24}
N 740 -420 740 310 {lab=#net20}
N 720 -420 740 -420 {lab=#net20}
N 1360 -510 1400 -510 {lab=#net25}
N 1360 -510 1360 480 {lab=#net25}
N 1330 -480 1400 -480 {lab=#net26}
N 1330 -480 1330 510 {lab=#net26}
N 1300 -450 1300 540 {lab=#net27}
N 1300 -450 1400 -450 {lab=#net27}
N 1270 -420 1400 -420 {lab=#net28}
N 1270 -420 1270 570 {lab=#net28}
N 1240 -390 1400 -390 {lab=#net29}
N 1240 -390 1240 600 {lab=#net29}
N 1210 -360 1400 -360 {lab=#net30}
N 1210 -360 1210 630 {lab=#net30}
N 1180 -330 1400 -330 {lab=#net31}
N 1180 -330 1180 660 {lab=#net31}
N 1150 -300 1400 -300 {lab=#net32}
N 1150 -300 1150 690 {lab=#net32}
N -790 210 -790 970 {lab=#net17}
N -740 30 -740 930 {lab=#net9}
N -670 480 -670 970 {lab=#net25}
N -470 510 -470 970 {lab=#net26}
N -270 540 -270 970 {lab=#net27}
N -340 110 -340 930 {lab=#net11}
N -540 70 -540 930 {lab=#net10}
N -590 250 -590 970 {lab=#net18}
N -390 280 -390 970 {lab=#net19}
N -180 310 -180 970 {lab=#net20}
N -130 150 -130 930 {lab=#net12}
N -60 570 -60 970 {lab=#net28}
N 60 340 60 970 {lab=#net21}
N 110 150 110 930 {lab=#net13}
N 320 110 320 930 {lab=#net14}
N 270 370 270 970 {lab=#net22}
N 390 630 390 970 {lab=#net30}
N 180 600 180 970 {lab=#net29}
N 470 400 470 970 {lab=#net23}
N 520 70 520 930 {lab=#net15}
N 720 30 720 930 {lab=#net16}
N 590 660 590 970 {lab=#net31}
N 790 690 790 970 {lab=#net32}
N 670 430 670 970 {lab=#net24}
N -470 510 1330 510 {lab=#net26}
N -670 480 1360 480 {lab=#net25}
N -270 540 1300 540 {lab=#net27}
N -60 570 1270 570 {lab=#net28}
N 180 600 1240 600 {lab=#net29}
N 390 630 1210 630 {lab=#net30}
N 590 660 1180 660 {lab=#net31}
N 790 690 1150 690 {lab=#net32}
N 1440 -270 1440 -160 {lab=von}
N 510 -270 510 -160 {lab=von}
N -470 -260 -470 -160 {lab=von}
N -1110 -120 1460 -120 {lab=von}
N -490 -260 -490 -120 {lab=von}
N 490 -270 490 -120 {lab=von}
N 1460 -270 1460 -120 {lab=von}
N -1170 -60 1480 -60 {lab=von}
N 1480 -270 1480 -60 {lab=von}
N 470 -270 470 -60 {lab=von}
N -510 -260 -510 -60 {lab=von}
N -1110 -760 -1110 -120 {lab=von}
N -1170 -760 -1170 -60 {lab=von}
N -1050 -760 -1050 -160 {lab=von}
N -1050 -160 1440 -160 {lab=von}
N -740 -770 -740 -630 {lab=VDD}
N 310 -780 310 -690 {lab=vin}
N 1550 -410 1630 -410 {lab=vout}
N 1630 -780 1630 -410 {lab=vout}
N -740 1150 1550 1150 {lab=GND}
N -740 1010 -740 1150 {lab=GND}
N -540 1010 -540 1150 {lab=GND}
N -340 1010 -340 1150 {lab=GND}
N -130 1010 -130 1150 {lab=GND}
N 110 1010 110 1150 {lab=GND}
N 320 1010 320 1150 {lab=GND}
N 520 1010 520 1150 {lab=GND}
N 720 1010 720 1150 {lab=GND}
N 1500 -270 1500 1150 {lab=GND}
N 450 -270 450 1140 {lab=GND}
N 450 1140 450 1150 {lab=GND}
N -530 -260 -530 1150 {lab=GND}
N -540 -890 -540 -500 {lab=VDD}
N -590 -890 -540 -890 {lab=VDD}
N -540 -890 420 -890 {lab=VDD}
N 1510 -890 1510 -510 {lab=VDD}
N 420 -890 1510 -890 {lab=VDD}
N 440 -890 440 -510 {lab=VDD}
N -160 -890 -160 -80 {lab=VDD}
N -190 -80 -160 -80 {lab=VDD}
N -190 -180 -160 -180 {lab=VDD}
N -190 -280 -160 -280 {lab=VDD}
N -190 -380 -160 -380 {lab=VDD}
N -190 -480 -160 -480 {lab=VDD}
N -190 -580 -160 -580 {lab=VDD}
N -190 -680 -160 -680 {lab=VDD}
N -190 -780 -160 -780 {lab=VDD}
N -210 -0 -190 -0 {lab=GND}
N -210 -100 -190 -100 {lab=GND}
N -210 -200 -190 -200 {lab=GND}
N -210 -300 -190 -300 {lab=GND}
N -210 -400 -190 -400 {lab=GND}
N -210 -500 -190 -500 {lab=GND}
N -210 -600 -190 -600 {lab=GND}
N -210 -700 -190 -700 {lab=GND}
N -210 -700 -210 1150 {lab=GND}
N -2110 660 -2110 700 {
lab=GND}
N -2110 570 -2110 600 {
lab=VDD}
N -1920 570 -1920 600 {
lab=von}
N -1920 660 -1920 700 {
lab=GND}
N -1840 570 -1840 600 {
lab=voff}
N -1840 660 -1840 700 {
lab=GND}
N -2000 570 -2000 600 {
lab=vin}
N -2000 660 -2000 700 {
lab=GND}
N -740 -770 -540 -770 {lab=VDD}
N -180 310 740 310 {lab=#net20}
C {DEMUX8.sym} -560 -390 0 0 {name=x1}
C {DEMUX8.sym} 420 -400 0 0 {name=x2}
C {MUX8.sym} 1420 -400 0 0 {name=x3}
C {IP62_5_stdcell/BUF_X4.sym} -220 -740 0 0 {name=x12}
C {IP62_5_stdcell/BUF_X4.sym} -220 -640 0 0 {name=x13}
C {IP62_5_stdcell/BUF_X4.sym} -220 -540 0 0 {name=x14}
C {IP62_5_stdcell/BUF_X4.sym} -220 -440 0 0 {name=x15}
C {IP62_5_stdcell/BUF_X4.sym} -220 -340 0 0 {name=x16}
C {IP62_5_stdcell/BUF_X4.sym} -220 -240 0 0 {name=x17}
C {IP62_5_stdcell/BUF_X4.sym} -220 -140 0 0 {name=x18}
C {IP62_5_stdcell/BUF_X4.sym} -220 -40 0 0 {name=x19}
C {devices/code.sym} -2080 -160 0 0 {name=TR10_MODELS
only_toplevel=true
format="tcleval( @value )"
value=".include $::LIB/../ip62_models"
spice_ignore=false}
C {devices/vsource.sym} -2110 630 0 0 {name=Vdd value=5.0 savecurrent=false}
C {devices/vdd.sym} -2110 570 0 0 {name=l3}
C {devices/gnd.sym} -2110 700 0 0 {name=l4}
C {devices/vsource.sym} -1920 630 0 0 {name=von value=5.0 savecurrent=false}
C {devices/lab_pin.sym} -1920 570 1 0 {name=p15 sig_type=std_logic lab=von}
C {devices/gnd.sym} -1920 700 0 0 {name=l5}
C {devices/vsource.sym} -1840 630 0 0 {name=voff value=0.0 savecurrent=false}
C {devices/lab_pin.sym} -1840 570 1 0 {name=p16 sig_type=std_logic lab=voff}
C {devices/gnd.sym} -1840 700 0 0 {name=l1}
C {devices/code_shown.sym} -2080 50 0 0 {name=spice only_toplevel=false value=".option savecurrent
.control
save all

* DC analysis (I/O curve)
dc vin 0 5.0 0.01
plot vout
wrdata ~/inverter_MUX8_02_tb.txt v(vout0)
write inverter_MUX8_02_tb.raw
.endc"}
C {devices/vsource.sym} -2000 630 0 0 {name=vin value=5.0 savecurrent=false}
C {devices/lab_pin.sym} -2000 570 1 0 {name=p17 sig_type=std_logic lab=vin}
C {devices/gnd.sym} -2000 700 0 0 {name=l2}
C {devices/gnd.sym} 1550 1150 0 0 {name=l7}
C {devices/vdd.sym} -590 -890 0 0 {name=l6}
C {devices/lab_pin.sym} 1630 -780 0 1 {name=p7 sig_type=std_logic lab=vout}
C {devices/lab_pin.sym} 310 -780 2 1 {name=p5 sig_type=std_logic lab=vin}
C {devices/lab_pin.sym} -1170 -760 2 1 {name=p1 sig_type=std_logic lab=von}
C {devices/lab_pin.sym} -1110 -760 2 1 {name=p2 sig_type=std_logic lab=von}
C {devices/lab_pin.sym} -1050 -760 2 1 {name=p3 sig_type=std_logic lab=von}
C {inv_LiBo.sym} -570 970 0 0 {name=x4}
C {inv_NaokiFukushima.sym} 290 970 0 0 {name=x5}
C {inv_lan.sym} -770 970 0 0 {name=x7}
C {inv_lihaitao.sym} -370 970 0 0 {name=x8}
C {inv_nakabuchi.sym} -160 970 0 0 {name=x9}
C {inv_nakashima.sym} 80 970 0 0 {name=x10}
C {inv_niimi.sym} 490 970 0 0 {name=x11}
C {inv_shotaro_mori.sym} 690 970 0 0 {name=x6}
